# IAR project BZ3102.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.CCIncludePath2: ..\USER; ..\System; ..\Hwa; ..\Driver; ..\App
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: BZ3102.hex
  ILINK.IlinkOutputFile: BZ3102.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NENCRYPT; NDEBUG
  OBJCOPY.OOCOutputFile: BZ3101.hex
  ILINK.IlinkOutputFile: BZ3101.out
  group App
    ../App/: app_config.c app_test.c
  group Driver
    ../Driver/: drive_led.c drive_scr.c
  group Hwa
    ../Hwa/: hwa_eeprom.c hwa_eeprom_cfg.c hwa_ntc.c
  group System
    ../System/: sys_adc.c sys_eeprom.c sys_iwdg.c sys_pwm.c sys_task.c sys_vector.c
